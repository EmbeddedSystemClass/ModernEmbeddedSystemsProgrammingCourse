# Keil uVision project lesson.uvprojx, settings and files
target dbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD_VL
  c include: .;..\qpc\3rd_party\CMSIS\Include;..\qpc\3rd_party\stm32f1-discovery
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Application
    ./: bsp.c main.c bsp.h
  group stm32f100rb
    ../qpc/3rd_party/stm32f1-discovery/: system_stm32f10x.c system_stm32f10x.h
    ../qpc/3rd_party/stm32f1-discovery/arm/: startup_stm32f10x_md_vl.s
    ../qpc/3rd_party//stm32f1-discovery/: stm32f10x.h
  group MiROS
    ./: miros.h miros.c
